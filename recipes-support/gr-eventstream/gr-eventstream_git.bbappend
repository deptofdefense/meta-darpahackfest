

PV = "0.0.5+git${SRCPV}"

SRC_URI = "git://github.com/flynn378/gr-eventstream;branch=master \
          "
S = "${WORKDIR}/git"

SRCREV = "0070c77ddd6a12020a4ff1de996f54749b220fa6"

