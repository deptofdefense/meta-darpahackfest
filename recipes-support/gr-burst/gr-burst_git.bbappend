

SRC_URI = "git://github.com/flynn378/gr-burst;branch=master \
           file://cross-64.patch \
          "


SRCREV = "ba78d5d145709ee0e24fbe59ee80c55fecfa064d"
