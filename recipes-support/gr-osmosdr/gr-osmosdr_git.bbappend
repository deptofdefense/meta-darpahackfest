PACKAGECONFIG = "uhd rtl-sdr  hackrf rfspace"
